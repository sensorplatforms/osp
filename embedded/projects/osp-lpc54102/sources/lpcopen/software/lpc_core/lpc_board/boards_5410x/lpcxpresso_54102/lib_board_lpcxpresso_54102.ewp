# IAR project lib_board_lpcxpresso_54102.ewp, settings and files
configuration lpcxpresso_54102 (ARM)
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\lpc_chip\chip_common; ..\..\..\lpc_chip\chip_5410x; ..\..\..\lpc_chip\chip_5410x\config; ..\..\board_common; ..\..\..\..\CMSIS\CMSIS\Include; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group board_lpcxpresso_54102
    ./: board.c board_sysinit.c
