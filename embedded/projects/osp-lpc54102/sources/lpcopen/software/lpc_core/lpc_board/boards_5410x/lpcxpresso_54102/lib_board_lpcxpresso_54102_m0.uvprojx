# Keil uVision project lib_board_lpcxpresso_54102_m0.uvprojx, settings and files
target lib_board_lpcxpresso_lpc54102_m0 (ARM-ADS)
  device: LPC54102:M0plus NXP
  pack: Keil.LPC54000_DFP.0.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_board_lpcxpresso_lpc54102_m0 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\lpc_chip\chip_common;..\..\..\lpc_chip\chip_5410x;..\..\..\lpc_chip\chip_5410x\config;..\..\..\lpc_chip\chip_5410x\cpat;..\..\..\lpc_board\board_common;..\..\..\..\CMSIS\CMSIS\Include;..\lpcxpresso_54102
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group bsp
    ./: board.c board_sysinit.c
