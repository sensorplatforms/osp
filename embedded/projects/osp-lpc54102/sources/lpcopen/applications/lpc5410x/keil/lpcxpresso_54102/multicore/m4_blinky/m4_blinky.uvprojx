# Keil uVision project m4_blinky.uvprojx, settings and files
target iflash_nxp_lpc540xx (ARM-ADS)
  device: LPC54102:M4 NXP
  pack: Keil.LPC54000_DFP.0.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: m4_blinky
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x\config;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x2000000 size 0x8000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group example
    ../../../../examples/multicore/m4master_blinky/: m4master_blinky.c readme.txt
    ../../../../startup/: keil_startup_lpc5410x.s sysinit.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/keil_output/core_m4/: lib_chip_5410x.lib
    ../../../../../../software/lpc_core/lpc_board/boards_5410x/lpcxpresso_54102/keil_output/core_m4/: lib_board_lpcxpresso_lpc54102.lib
