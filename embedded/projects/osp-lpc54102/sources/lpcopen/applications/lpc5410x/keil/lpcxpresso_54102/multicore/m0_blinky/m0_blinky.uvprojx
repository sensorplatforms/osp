# Keil uVision project m0_blinky.uvprojx, settings and files
target iflash_nxp_lpc540xx (ARM-ADS)
  device: LPC54102:M0plus NXP
  pack: Keil.LPC54000_DFP.0.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: m0_blinky
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS __MULTICORE_M0SLAVE
  c include: ..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x\config;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102
  asm define: SLAVEBOOT NO_CRP
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT9: RAM 0x2008000 size 0x8000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group example
    ../../../../examples/multicore/m0slave_blinky/: m0slave_blinky.c readme.txt
    ../../../../startup/: sysinit.c keil_startup_lpc5410x-m0.s
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/keil_output/core_m0/: lib_chip_5410x_m0.lib
