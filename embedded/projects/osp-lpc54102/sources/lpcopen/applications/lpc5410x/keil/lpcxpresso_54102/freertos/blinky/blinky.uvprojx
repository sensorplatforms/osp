# Keil uVision project blinky.uvprojx, settings and files
target iflash_nxp_lpcxpresso_lpc5410x (ARM-ADS)
  device: LPC54102:M4 NXP
  pack: Keil.LPC54000_DFP.0.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_blinky
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x\config;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\software\freertos\freertoslpc;..\..\..\..\examples\freertos\blinky
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group example
    ../../../../examples/freertos/startup/: keil_startup_lpc5410x.s
    ../../../../examples/freertos/blinky/: readme.txt blinky.c
    ../../../../startup/: sysinit.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/keil_output/core_m4/: lib_chip_5410x.lib
    ../../../../../../software/lpc_core/lpc_board/boards_5410x/lpcxpresso_54102/keil_output/core_m4/: lib_board_lpcxpresso_lpc54102.lib
  group FreeRTOS
    ../../../../../../software/freertos/freertos/Source/: timers.c tasks.c queue.c list.c croutine.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
