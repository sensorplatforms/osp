# IAR project uart_int_sfifo.ewp, settings and files
configuration iflash_nxp_lpcxpresso_54000 (ARM)
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x\config; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 0
  OBJCOPY.OOCOutputFile: blinky.bin
  ILINK.IlinkOutputFile: rom_uart_int_sfifo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../../examples/rom/uart_int_sfifo/: uart_int_sfifo.c readme.txt
    ../../../../startup/: iar_startup_lpc5410x.s sysinit.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_5410x/lpcxpresso_54102/iar_output/Exe/: board_lpcxpresso_54102.a
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/iar_output/Exe/: chip_5410x_lib.a
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/power_lib/iar/: lib_power.a
