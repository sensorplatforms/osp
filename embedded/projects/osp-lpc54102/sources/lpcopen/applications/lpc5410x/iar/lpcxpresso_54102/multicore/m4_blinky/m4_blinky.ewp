# IAR project m4_blinky.ewp, settings and files
configuration multicore_m4_blinky (ARM)
  General.OGChipSelectEditMenu: LPC1549 NXP LPC1549
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x\config; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: m4_blinky.bin
  ILINK.IlinkOutputFile: multicore_m4_blinky.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\applications\lpc5410x\examples\multicore\m4master_blinky\LPC540xx_m4_map.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../examples/multicore/m4master_blinky/: readme.txt
  group example
    ../../../../startup/: iar_startup_lpc5410x.s sysinit.c
    ../../../../examples/multicore/m4master_blinky/: m4master_blinky.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_5410x/lpcxpresso_54102/iar_output/Exe/: board_lpcxpresso_54102.a
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/iar_output/Exe/: chip_5410x_lib.a
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/power_lib/iar/: lib_power.a
