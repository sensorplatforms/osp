# IAR project m0_blinky.ewp, settings and files
configuration multicore_m0_blinky (ARM)
  General.OGChipSelectEditMenu: LPC54102J512_M0PL NXP LPC54102J512_M0PL
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS; __MULTICORE_M0SLAVE
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x\config; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_5410x; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: SLAVEBOOT; NO_CRP
  OBJCOPY.OOCOutputFile: m0_blinky.bin
  ILINK.IlinkOutputFile: multicore_m0_blinky.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\applications\lpc5410x\examples\multicore\m0slave_blinky\LPC540xx_m0_map.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../examples/multicore/m0slave_blinky/: readme.txt
  group example
    ../../../../startup/: iar_startup_lpc5410x-m0.s sysinit.c
    ../../../../examples/multicore/m0slave_blinky/: m0slave_blinky.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_5410x/iar_output_m0/Exe/: chip_5410x_lib_m0.a
