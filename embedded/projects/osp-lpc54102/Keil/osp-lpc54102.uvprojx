# Keil uVision project osp-lpc54102.uvprojx, settings and files
target OSP-Reference (ARM-ADS)
  device: LPC54102:M4 NXP
  pack: Keil.LPC54000_DFP.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OspSensorHub
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: INTERNAL_FLASH,BOARD_NXP_LPCXPRESS0_54102,PWRROMD_PRESENT,__FPU_PRESENT=1,CORE_M4,ANDROID_DEMO,DEBUG_BUILD,DEBUG_OUTPUT,ASF_PROFILING,ON_DEMAND_PROFILING
  c include: ..\..\..\..\include;..\..\..\common\app;..\..\..\common\asf;..\..\..\common\alg;..\sources\app;..\sources\config;..\sources\boardsupport;..\..\..\common\modules\sensor-drivers;..\..\..\common\modules\bus-drivers;..\..\..\..\external\rtos\rtx\inc;..\..\..\..\external\rtos\rtx\cm;..\sources\lpcopen\software\lpc_core\lpc_board\boards_5410x\lpcxpresso_54102;..\sources\lpcopen\software\lpc_core\lpc_chip\chip_5410x;..\sources\lpcopen\software\lpc_core\lpc_chip\chip_common;..\sources\lpcopen\software\lpc_core\lpc_chip\chip_5410x\config;..\sources\lpcopen\software\lpc_core\lpc_board\board_common;..\sources\HostInterface;..\..\..\..\include\hal;..\..\..\..\targets\TARGET_LPC54102
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group ASF
    ../../../common/asf/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../sources/config/: rtx_conf_cm.c
    C:/Keil_v5/ARM/RL/RTX/CM4F_LE_IFX/: RTX_CM4_IFX.lib
  group Alg
    ../../../common/alg/: osp_embeddedalgcalls.c stepdetector.c stepsegmenter.c signalgenerator.c significantmotiondetector.c
  group App-Common
    ../../../common/app/: algorithm_t.c instrmgr_t.c instrmgr_user.c sensoracq_t.c cmdhandler_t.c
  group App
    ../sources/app/: console_util.c i2c_slavecomm_t.c main.c taskinit_user.c hostif_i2c.c fmlib_hostif.c sysinit.c
    ../../../fmlib/: FMLib_Embedded.lib
    ../sources/HostInterface/: SensorPackets.c BlockMemory.c Queue.c
    ../sources/lpcopen/software/lpc_core/lpc_board/boards_5410x/lpcxpresso_54102/keil_output/core_m4/: lib_board_lpcxpresso_lpc54102.lib
    ../sources/lpcopen/software/lpc_core/lpc_chip/chip_5410x/keil_output/core_m4/: lib_chip_5410x.lib
    ../sources/lpcopen/applications/lpc5410x/startup/: keil_startup_lpc5410x.s
    ../../../common/app/: debugprint.c
  group Bus-Drivers
    ../sources/boardsupport/: sensacq_i2c.c
  group Sensor-Drivers
    ../../../common/modules/sensor-drivers/: bmp280.c BMG160.c bmm050.c bma2x2.c
  group TARGET_LPC54102
    ../../../../targets/TARGET_LPC54102/: gpio_api.c gpio_irq_api.c pinmap.c rtc_api.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0
