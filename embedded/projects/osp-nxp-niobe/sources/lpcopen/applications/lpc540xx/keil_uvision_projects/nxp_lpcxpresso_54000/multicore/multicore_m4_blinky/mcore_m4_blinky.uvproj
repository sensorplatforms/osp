# Keil uVision project mcore_m4_blinky.uvproj, settings and files
target iflash_nxp_lpc540xx (ARM-ADS)
  device: ARMCM4 ARM
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(10000000) ELITTLE
  output: multicore_m4_blinky
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_540xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_540xx\config;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_540xx\nxp_lpcxpresso_54000
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x2000000 size 0x8000
  group example
    ../../../../examples/multicore/m4master_blinky/: m4master_blinky.c readme.txt
    ../../../../startup_code/: sysinit.c keil_startup_lpc540xx.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_540xx/nxp_lpcxpresso_54000/keil_output/core_m4/: board_nxp_lpcxpresso_lpc540xx.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_540xx/keil_output/core_m4/: chip_540xx_lib.lib
