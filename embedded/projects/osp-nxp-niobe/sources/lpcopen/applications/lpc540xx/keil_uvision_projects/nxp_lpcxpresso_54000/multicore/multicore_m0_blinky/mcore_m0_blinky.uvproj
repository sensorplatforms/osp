# Keil uVision project mcore_m0_blinky.uvproj, settings and files
target iflash_nxp_lpc540xx (ARM-ADS)
  device: ARMCM0P ARM
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(10000000) ELITTLE
  output: multicore_m0_blinky
  c flags: Optim=4 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_540xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_540xx\config;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_540xx\nxp_lpcxpresso_54000
  asm define: SLAVEBOOT NO_CRP
  memory RVCT4: ROM 0x20000 size 0x20000
  memory RVCT9: RAM 0x2008000 size 0x8000
  group example
    ../../../../startup_code/: sysinit.c keil_startup_lpc540xx_m0.s
    ../../../../examples/multicore/m0slave_blinky/: m0slave_blinky.c readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_540xx/nxp_lpcxpresso_54000/keil_output/core_m0plus/: board_nxp_lpcxpresso_lpc540xx_m0.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_540xx/keil_output/core_m0plus/: chip_540xx_lib_m0.lib
