<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_540xx\nxp_lpcxpresso_54000\lib_lpc_board_nxp_lpcxpresso_54000.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_540xx\lib_lpc_chip_540xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_blinky\periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_uart_rb\periph_uart_rb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_adc\periph_adc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_adc_dma_rom\periph_adc_dma_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_bod\periph_bod.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_crc\periph_crc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_ctimer\periph_ctimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_dma\periph_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_dma_rom\periph_dma_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_flashiap\periph_flashiap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_freqmeasure\periph_freqmeasure.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_gint\periph_gint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_i2cm_interrupt\periph_i2cm_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_i2cs_interrupt\periph_i2cs_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_i2cs_interrupt_dma\periph_i2cs_interrupt_dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_i2c_rom\periph_i2c_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_i2c_rom_slave\periph_i2c_rom_slave.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_mrt\periph_mrt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_ostimer\periph_ostimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_pinint\periph_pinint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_rtc\periph_rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_sct\periph_sct.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_sct_pwm\periph_sct_pwm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_spi_rom\periph_spi_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_spi_rom_interrupt\periph_spi_rom_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_spi_sm_int\periph_spi_sm_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_uart_rom_int\periph_uart_rom_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_uart_rom_polling\periph_uart_rom_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_utick\periph_utick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_wwdt\periph_wwdt.ewp</path>
  </project>
  <batchBuild/>
</workspace>


