# IAR project freertos_blinky.ewp, settings and files
configuration iflash_nxp_lpcxpresso_54000 (ARM)
  General.OGChipSelectEditMenu: LPC1549 NXP LPC1549
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_540xx\config; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_540xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_540xx\nxp_lpcxpresso_54000; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\examples\freertos\freertos_blinky
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\examples\freertos\freertos_blinky
  OBJCOPY.OOCOutputFile: freertos_blinky.bin
  ILINK.IlinkOutputFile: freertos_blinky.out
  ILINK.IlinkIcfFile: ..\..\..\..\tool_configs\iar_linker_scripts\LPC540xx_heap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../../examples/freertos/freertos_blinky/: freertos_blinky.c
    ../../../../startup_code/: iar_startup_lpc540xx.s sysinit.c
  group freertos
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c timers.c
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_540xx/nxp_lpcxpresso_54000/iar_output/Exe/: board_nxp_lpcxpresso_54000.a
    ../../../../../../software/lpc_core/lpc_chip/chip_540xx/iar_output/Exe/: chip_540xx_lib.a
    ../../../../../../software/lpc_core/lpc_chip/chip_540xx/pmu_library/iar/: pmu_library.a
