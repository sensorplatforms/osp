# IAR project multicore_m4_blinky.ewp, settings and files
configuration multicore_m4_blinky (ARM)
  General.OGChipSelectEditMenu: LPC1549 NXP LPC1549
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_540xx\config; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_540xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_540xx\nxp_lpcxpresso_54000; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: multicore_m4_blinky.bin
  ILINK.IlinkOutputFile: multicore_m4_blinky.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\applications\lpc540xx\examples\multicore\m4master_blinky\LPC540xx_m4_map.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../examples/multicore/m4master_blinky/: readme.txt
  group example
    ../../../../startup_code/: iar_startup_lpc540xx.s sysinit.c
    ../../../../examples/multicore/m4master_blinky/: m4master_blinky.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_540xx/nxp_lpcxpresso_54000/iar_output/Exe/: board_nxp_lpcxpresso_54000.a
    ../../../../../../software/lpc_core/lpc_chip/chip_540xx/iar_output/Exe/: chip_540xx_lib.a
    ../../../../../../software/lpc_core/lpc_chip/chip_540xx/pmu_library/iar/: pmu_library.a
