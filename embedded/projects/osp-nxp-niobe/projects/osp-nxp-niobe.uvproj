# Keil uVision project osp-nxp-niobe.uvproj, settings and files
target OSP-Reference (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: OspSensorHub
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: INTERNAL_FLASH,LPC54xxx_XPRESSO_BOARD,FM_PLATFORM_LPC43XX_EVM,PWRROMD_PRESENT,__FPU_PRESENT=1,CORE_M4,ANDROID_DEMO,DEBUG_BUILD,DEBUG_OUTPUT,ASF_PROFILING,ON_DEMAND_PROFILING
  c include: ..\..\..\..\include;..\..\..\common\app;..\..\..\common\asf;..\..\..\common\alg;..\sources\app;..\sources\config;..\sources\boardsupport;..\..\..\common\modules\sensor-drivers;..\..\..\common\modules\bus-drivers;..\..\..\..\external\rtos\rtx\inc;..\..\..\..\external\rtos\rtx\cm;..\sources\lpcopen\software\lpc_core\lpc_board\boards_540xx\nxp_lpcxpresso_54000;..\sources\lpcopen\software\lpc_core\lpc_chip\chip_540xx;..\sources\lpcopen\software\lpc_core\lpc_chip\chip_common;..\sources\lpcopen\software\lpc_core\lpc_chip\chip_540xx\config;..\sources\lpcopen\software\lpc_core\lpc_board\board_common;..\sources\HostInterface
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x18000
  group ASF
    ../../../common/asf/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../sources/config/: rtx_conf_cm.c
    C:/Keil5/ARM/RL/RTX/CM4F_LE_IFX/: RTX_CM4_IFX.lib
  group Alg
    ../../../common/alg/: osp_embeddedalgcalls.c stepdetector.c stepsegmenter.c signalgenerator.c significantmotiondetector.c
  group App-Common
    ../../../common/app/: algorithm_t.c instrmgr_t.c instrmgr_user.c osp-api.c sensoracq_t.c
  group App
    ../sources/app/: console_util.c i2c_slavecomm_t.c main.c taskinit_user.c hostif_i2c.c fmlib_hostif.c keil_startup_lpc540xx.s sysinit.c keil_startup_lpc412x.s
    ../sources/lpcopen/software/lpc_core/lpc_chip/chip_540xx/keil_output/core_m4/: chip_540xx_lib.lib
    ../sources/lpcopen/software/lpc_core/lpc_board/boards_540xx/nxp_lpcxpresso_54000/keil_output/core_m4/: board_nxp_lpcxpresso_lpc540xx.lib
    ../../../fmlib/: FMLib_Embedded.lib fmlib_algorithm.c
    ../sources/HostInterface/: SensorPackets.c BlockMemory.c Queue.c
  group Bus-Drivers
    ../sources/boardsupport/: sensacq_i2c.c
  group Sensor-Drivers
    ../../../common/modules/sensor-drivers/: bmp280.c BMG160.c bmm050.c bma2x2.c
